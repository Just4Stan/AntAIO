File: OpenRX-Gemini/clock.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: annotate
Other:
- note added: "07/06/2026"
- note added: "1"
- note added: "clock"
